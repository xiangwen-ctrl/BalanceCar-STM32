# Keil uVision project BalanceCar.uvprojx, settings and files
target BalanceCar (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BalanceCar +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --locale=english
  c include: ..\user;..\user\api;..\STM32F10x_StdPeriph_Driver\inc;..\user\api\oled;..\MPU6050\eMPL;..\project;..\user\api\MPU6050;..\user\api\MPU6050\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../startup/: startup_stm32f10x_hd.s
  group User
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c
    ../user/api/: picture.c
  group User/api
    ../user/api/: delay.c LED.c usart1.c oled.c motor.c encoder.c ble.c control.c steer.c wifi.c sr04.c
  group Stdlib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Picture
    ./: landscape.c
  group MPU6050
    ../user/api/MPU6050/: mpuiic.c mpu6050.c
    ../user/api/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
software components: CMSIS:CORE 5.4.0
